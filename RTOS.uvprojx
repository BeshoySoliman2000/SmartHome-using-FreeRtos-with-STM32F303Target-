# Keil uVision project RTOS.uvprojx, settings and files
target STM32F303 (6160000::V6.16::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc\LIB;.\inc\RCC;..\New RTOS proj;.\inc\GPIO;.\inc\LCD;.\inc\02 - KEYPAD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: main.c RCC.c GPIO.c LCD.c KEYPAD_prg.c
    ./inc/RCC/: RCC.h RCC_cfg.h RCC_prv.h
    ./inc/LIB/: Bit_utils.h Std_types.h
    ./inc/GPIO/: GPIO.h GPIO_cfg.h GPIO_prv.h
    ./inc/LCD/: LCD.h
    ./inc/02 - KEYPAD/: KEYPAD_cfg.h KEYPAD_int.h KEYPAD_prv.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.11.3
